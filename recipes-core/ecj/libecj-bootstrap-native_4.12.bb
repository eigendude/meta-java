require libecj-bootstrap.inc

PR = "${INC_PR}.0"

SRC_URI = "http://archive.eclipse.org/eclipse/downloads/drops4/R-4.12-201906051800/ecjsrc-${PV}.jar"

SRC_URI[md5sum] = "ac41d00b2c683e086f6f1c2861f9716d"
SRC_URI[sha256sum] = "d42c8ae16f590cbade9700525263b31cb723f278ee22dbf72d1c5e3c4d48db71"
